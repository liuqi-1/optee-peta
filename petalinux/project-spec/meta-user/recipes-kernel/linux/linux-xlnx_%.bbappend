FILESEXTRAPATHS_prepend := "${THISDIR}/linux-xlnx:"
SRC_URI_append += "file://kernel_optee.cfg"
