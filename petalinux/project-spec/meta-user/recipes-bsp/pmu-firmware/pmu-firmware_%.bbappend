## remove the xilfpga from pmu-firmware

# ILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
# SRC_URI += "file://0001-remove-xilfpga-library.patch"

